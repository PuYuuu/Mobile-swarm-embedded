# Keil uVision project MobilSwarm.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MobilSwarm +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\BOT_BSP;..\BOT_BSP\DMP;..\BOT_APP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: startup_stm32f10x_hd.s MobileSwarm.c
  group BOT_APP
    ../BOT_APP/: app_control.c app_show.c app_communicate.c
  group BOT_BSP
    ../BOT_BSP/: bsp_adc.c bsp_led.c bsp_key.c bsp_exti.c bsp_oled.c bsp_motor.c bsp_usartx.c bsp_pstwo.c bsp_iic.c bsp_encoder.c bsp_mpu6050.c
    ../BOT_BSP/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
